# Repository stan23/myPCBs

File README.md:

# myPCBs

Dies ist eine Sammplung meiner Platinen für HomeMatic, AskSinPP und weiteres für's Smarthome.

## AskSin Analyzer Platine
Eine Platine für [Jérômes AsksinAnalyzer](https://github.com/jp112sdl/AskSinAnalyzer).

[Link zum Projekt](https://github.com/stan23/myPCBs/tree/master/AskSinAnalyzer)

## HB-UNI-Sen-CAP-MOIST-T Platine
Eine Platine für [Jérômes Feuchtigkeitssensor](https://github.com/jp112sdl/HB-UNI-Sen-CAP-MOIST).

[Link zum Projekt](https://github.com/stan23/myPCBs/tree/master/HB-UNI-Sen-CAP-MOIST-T)

## HB-Dis-EP-42BW Platine
Eine Platine für [Jérômes 4,2" ePaper Display](https://github.com/jp112sdl/HB-Dis-EP-42BW).

[Link zum Projekt](https://github.com/jp112sdl/HB-Dis-EP-42BW/tree/master/PCB)

## HB-Mower-Fence Platine
Ein Signalgenerator für den Begrenzungsdraht von WORX Rasenmäherrobotern, das sich wie ein HomeMatic Schaltaktor verhält.

[Link zum Projekt](https://github.com/stan23/myPCBs/tree/master/HB-Mower-Fence)

## HB-MOD-UART Platine
Eine Platine für das HM-MOD-UART Funkmodul mit SMA-Anschluss für eine externe Antenne.

[Link zum Projekt](https://github.com/stan23/myPCBs/tree/master/HB-MOD-UART)

## HB-MOD-UART-USB Platine
Ein USB-Stick mit HM-MOD-UART Funkmodul und FT232R, basierend auf @alexreinert's [HB-RF-USB](https://github.com/alexreinert/PCB/#hb-rf-usb). 

[Link zum Projekt](https://github.com/stan23/myPCBs/tree/master/HB-MOD-UART-USB)

## HM-LC-Bl1-FM-DC Platine
Eine Platine für den Nachbau eines HM-LC-Bl1-FM Rollladenaktors für Gleichstrommotoren (12 V oder 24 V).

[Link zum Projekt V3.0](https://github.com/stan23/myPCBs/tree/master/HM-LC-Bl1-FM-DC)
[Link zum Projekt V2.x](https://github.com/stan23/HM-LC-Bl1-FM-DC)

## HM-ES-PMSw1-Pl_GosundSP1 Platine
Eine Platine zum Umbau des Gosund SP1 Wifi-Steckers zu einem HM-ES-PMSw1-Pl Messaktor.

[Link zum Projekt](https://github.com/stan23/HM-ES-PMSw1-Pl_GosundSP1)

## HM-LC-Sw1-Pl-DN-R1_OBI Platine
Eine Platine zum Umbau des OBI-Wifi-Steckers zu einem HM-LC-Sw1-Pl-DN-R1.

[Link zum Projekt](https://github.com/stan23/HM-LC-Sw1-Pl-DN-R1_OBI)

### Unbestückte Platinen gebe ich gerne zum Selbstkostenpreis ab.

## KiCad design HB-LC-Dim5PWM-CV_AskSinDuino32Shield/HB-LC-Dim5PWM-CV_AskSinDuino32Shield.kicad_pcb

Parts:
C1: 10u 50V; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2: 22u 10V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C21, C22, C23, C24, C25: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
H1: MountingHole; MountingHole_3.2mm_M3
H2: MountingHole; MountingHole_3.5mm
J1: power+LED; P-250-208
J2: Encoder 1; PinHeader_1x05_P2.54mm_Vertical
J3: Encoder 2; PinHeader_1x05_P2.54mm_Vertical
JP1: direct_3V3; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q11, Q12, Q13, Q14, Q15: IRF8788PbF; SOIC-8_3.9x4.9mm_P1.27mm
R11, R13, R15, R17, R19: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12, R14, R16, R18, R20: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R22, R23, R24: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: AskSinDuino32
U2: DS18B20; TO-92_Inline
U3: LC78_05-0.5; SIP3_11.6x6.0mm

Connections:
+3V3: C25.1, J2.4, J3.4, JP1.2 (B), R25.1, U1.3V3, U2.3 (V_{DD})
+5V: C2.1, JP1.1 (A), U1.E12 (RAW), U3.3 (OUT)
+24V: C1.1, J1.6, J1.7, U3.1 (IN)
/1WIRE: R25.2, U1.W12 (PA1), U2.2 (DQ)
/CLK1: R21.2, U1.E10 (PB8)
/CLK2: R23.2, U1.E5 (PB3)
/DATA1: R22.2, U1.E8 (PB6)
/DATA2: R24.2, U1.E4 (PA15)
/LED1: J1.5, Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D)
/LED2: J1.4, Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D)
/LED3: J1.3, Q13.5 (D), Q13.6 (D), Q13.7 (D), Q13.8 (D)
/LED4: J1.2, Q14.5 (D), Q14.6 (D), Q14.7 (D), Q14.8 (D)
/LED5: J1.1, Q15.5 (D), Q15.6 (D), Q15.7 (D), Q15.8 (D)
/PWM1: R11.1, U1.W8 (PA5)
/PWM2: R13.1, U1.W7 (PA6)
/PWM3: R15.1, U1.W6 (PA7)
/PWM4: R17.1, U1.W5 (PB0)
/PWM5: R19.1, U1.W4 (PB1)
/SW1: J2.3, U1.E9 (PB7)
/SW2: J3.3, U1.E3 (PA12)
GND: C1.2, C2.2, C21.2, C22.2, C23.2, C24.2, C25.2, J1.8, J2.5, J3.5, Q11.1 (S), Q11.2 (S), Q11.3 (S), Q12.1 (S), Q12.2 (S), Q12.3 (S), Q13.1 (S), Q13.2 (S), Q13.3 (S), Q14.1 (S), Q14.2 (S), Q14.3 (S), Q15.1 (S), Q15.2 (S), Q15.3 (S), R12.1, R14.1, R16.1, R18.1, R20.1, U1.GND, U1.W2 (BOOT0), U2.1 (GND), U3.2 (GND)
unnamed: C21.1, J2.1, R21.1
unnamed: C22.1, J2.2, R22.1
unnamed: C23.1, J3.1, R23.1
unnamed: C24.1, J3.2, R24.1
unnamed: Q11.4 (G), R11.2, R12.2
unnamed: Q12.4 (G), R13.2, R14.2
unnamed: Q13.4 (G), R15.2, R16.2
unnamed: Q14.4 (G), R17.2, R18.2
unnamed: Q15.4 (G), R19.2, R20.2

Notes on the sheet:
v0.2: - fix rotary encoder - DCDC for 5V, onboard LDO for 3V3 - reconnect pins for easier routing v0.3: - routing optimization v0.4: - diodes removed - smaller FETs - 5th channel
v0.5: - routing improvements v0.6: - wrong VCC connection fixed in footprint
short if DCDC output is 3V3

Board: 2 copper layers, 62.0 x 37.4 mm, 36 parts (0 on the bottom side), 30 nets.

## KiCad design HB-LC-Dim6PWM-CV/HB-LC-Dim6PWM-CV.kicad_pcb

Board: 2 copper layers, 57 parts (0 on the bottom side), 40 nets, no tracks yet.

Parts:
C1: 10u/50V; C_0805_HandSoldering
C2: 22u/6.3V; C_0805_HandSoldering
C3, C4, C5, C7, C9: 100n; C_0805_HandSoldering
C6: 1u; C_0805_HandSoldering
C8: 10u; C_0805_HandSoldering
D1: LED; LED_0805_HandSoldering
D10, D20, D30, D40, D50, D60: SS14; D_SMA_Handsoldering
J1: ANT; Pin_Header_Straight_1x01_Pitch2.54mm
J2: Power; bornier2
J4, J30, J40, J50, J60: LED1; bornier2
J10: ISP; Pin_Header_Straight_2x03_Pitch2.54mm_Tight_Fit
J11: FTDI; Pin_Header_Straight_1x06_Pitch2.54mm_Tight_Fit
J20: LED2; bornier2
Q10, Q20, Q30, Q40, Q50, Q60: IRF3708; TO-220_Vertical
R1, R4, R5: 10k; R_0805_HandSoldering
R2: 4k7; R_0805_HandSoldering
R3: 1k5; R_0805_HandSoldering
R10, R20, R30, R40, R50, R60: 100; R_0805_HandSoldering
R11, R21, R31, R41, R51, R61: 100k; R_0805_HandSoldering
SW1: SW_Push; SW_SPST_B3U-1000P
U1: R-78E3.3-0.5; DCDC-Conv_Recom_R-78HBxx-0.5
U2: ATmega328P-AU; TQFP-32_7x7mm_Pitch0.8mm_HandSoldering
U3: CC1101; CC1101_SMD_noGDO2_Antenna
U4: PCA9685PW; TSSOP-28_4.4x9.7mm_Pitch0.65mm
U5: DS18B20; TO-92_Inline_Narrow_Oval
U6: AT24CS32; SOIC-8_3.9x4.9mm_Pitch1.27mm
Y1: 8M; Resonator_SMD_muRata_CSTCC-CSTCE-universal-3pin_7.2x3.0mm_H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

Connections:
1WIRE: R2.2, U2.1, U5.2
+3V3: C2.1, C3.1, C4.1, C6.1, C8.1, C9.1, J10.2, J11.4, R1.1, R2.1, R5.1, U1.3, U2.4, U2.6, U2.18, U3.1, U4.28, U5.3, U6.8
CONFIG: SW1.1, U2.12
CS: U2.14, U3.8
GDO0: U2.32, U3.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, D1.1, J2.2, J10.6, J11.5, J11.6, Q10.3, Q20.3, Q30.3, Q40.3, Q50.3, Q60.3, R11.1, R21.1, R31.1, R41.1, R51.1, R61.1, SW1.2, U1.2, U2.3, U2.5, U2.21, U3.2, U3.10, U3.11, U4.1, U4.2, U4.3, U4.4, U4.5, U4.14, U4.23, U4.24, U4.25, U5.1, U6.1, U6.2, U6.3, U6.4, U6.7, Y1.2
LED: R3.1, U2.2
MISO: J10.1, U2.16, U3.5
MOSI: J10.4, U2.15, U3.3
unnamed: C5.1, U2.20
unnamed: C7.2, J11.1
unnamed: D1.2, R3.2
unnamed: D10.2, J4.2, Q10.2
unnamed: D20.2, J20.2, Q20.2
unnamed: D30.2, J30.2, Q30.2
unnamed: D40.2, J40.2, Q40.2
unnamed: D50.2, J50.2, Q50.2
unnamed: D60.2, J60.2, Q60.2
unnamed: J1.1, U3.9
unnamed: Q10.1, R10.1, R11.2
unnamed: Q20.1, R20.1, R21.2
unnamed: Q30.1, R30.1, R31.2
unnamed: Q40.1, R40.1, R41.2
unnamed: Q50.1, R50.1, R51.2
unnamed: Q60.1, R60.1, R61.2
unnamed: U2.7, Y1.1
unnamed: U2.8, Y1.3
PWM1: R10.2, U4.6
PWM2: R20.2, U4.7
PWM3: R30.2, U4.8
PWM4: R40.2, U4.9
PWM5: R50.2, U4.10
PWM6: R60.2, U4.11
RESET: C7.1, J10.5, R1.2, U2.29
RX: J11.2, U2.30
SCL: R4.2, U2.28, U4.26, U6.6
SCLK: J10.3, U2.17, U3.4
SDA: R5.2, U2.27, U4.27, U6.5
TX: J11.3, U2.31
VBUS: C1.1, D10.1, D20.1, D30.1, D40.1, D50.1, D60.1, J2.1, J4.1, J20.1, J30.1, J40.1, J50.1, J60.1, U1.1

## KiCad design HM-LC-Bl1-FM-DC/HM-LC-Bl1-FM-DC.kicad_pcb

File HM-LC-Bl1-FM-DC/README.md:

# HM-LC-Bl1-FM-DC          
Nachbau HM-LC-Bl1-FM Rollladenaktor für Gleichstrommotoren (z.B. Plissee)

Er verhält sich wie ein Rolloaktor, treibt aber einen 12 V bzw. 24 V Gleichstrommotor. Dieser wird je nach Fahrtrichtung umgepolt.

Diese Seite beschreibt Version 3.0 der Platine. Version 2.x ist [hier zu finden](https://github.com/stan23/HM-LC-Bl1-FM-DC).

## Hardware

### Bauteile

#### Reichelt

[Bestellliste](https://www.reichelt.de/my/2126751)

Bauteil                  | Bestellnummer   | Anzahl | Kommentar
------------------------ | --------------- | ------ | ---------
C1, C2, C4, C8, C21, C22 | X7R-G0603 100N  |   6    | -
C3                       | 1u  |   1    | -
C6                       | X5R-G0603 10/6  |   1    | -
C7                       | TAJ 3528 3,3/35 |   1    |  -
R1, R3, R21, R23         | RND 0603 1 10K  |   4    | -
R2                       | RND 0603 1 1,5K |   2    | -
R11, R12                 | RND 0603 1 2,7K |   2    | -
R22, R24                 | RND 0603 1 47   |   1    | -
D1                       | SLO SMD-Y0603-0 |   1    | -
D2, D11, D12             | 1N 4148 WS      |   3    | -
Q1, Q2                   | BC 817 NXP      |   2    | -
U1                       | ATMEGA 328P-AU  |   1    | -
U3                       | SIM1-1203 SIL4  |   1    | alternativ für 12 V
U3                       | SIM1-2403 SIL4  |   1    | alternativ für 24 V
K1, K2                   | G6S-2 12V       |   2    | alternativ für 12 V
K1, K2                   | G6S-2 24V       |   2    | alternativ für 24 V
X1                       | WAGO 250-204    |   1    | Klemme für Netzeil und Motor
X2                       | WAGO 250-403    |   1    | Klemme für Bedientaster

#### Sonstiges

Bauteil | Bestellnummer            | Anzahl | Kommentar
------- | ------------------------ | ------ | ---------
U2      | CC1101 Funkmodul 868MHz  |   1    | z.B. [eBay](https://www.ebay.de/itm/272455136087)
SW2     |                          |   1    | Taster

### Programmieradapter
- 1x ISP (um den Bootloader zu brennen)
- 1x FTDI Adapter (falls nicht schon vorhanden, gibts bei [Amazon](https://www.amazon.de/FT232RL-FTDI-USB-auf-TTL-Serienadapter-Arduino/dp/B00HSXDGOE))

## Software

### Fuses

Low:  0xE2
High: 0xD2
Ext:  0xFF

### Bootloader

Aus der Arduino IDE, für ATmega328P, 3,3 V, 8 MHz

### Firmware

https://github.com/pa-pa/AskSinPP/tree/master/examples/HM-LC-Bl1-FM

## Bilder

Dieses Werk ist lizenziert unter einer [Creative Commons Namensnennung - Nicht-kommerziell - Weitergabe unter gleichen Bedingungen 4.0 International Lizenz](http://creativecommons.org/licenses/by-nc-sa/4.0/).

Board: 2 copper layers, 59.7 x 27.9 mm, 35 parts (1 on the bottom side), 31 nets.

Parts:
C1, C2, C4, C8, C21, C22: 100n; C_0805_HandSoldering
C3: 1u; C_0805_HandSoldering
C6: 10u; C_0805_HandSoldering
C7: 3.3u 35V; CP_Tantalum_Case-C_EIA-6032-28_Reflow
D1: LED; LED_0805_HandSoldering
D2, D11, D12: 1N4148; D_SOD-323_HandSoldering
J1: Conn_01x01; Measurement_Point_Square-TH_Small
J2: FTDI; Pin_Header_Straight_1x06_Pitch2.54mm_Tight_Fit
J3: ISP; Pin_Header_Straight_2x03_Pitch2.54mm_Tight_Fit
K1, K2: OMRONG6S-2; Relay_Omron_G6S-2
Q1, Q2: BC817; SOT-23_Handsoldering
R1, R3, R21, R23: 10k; R_0805_HandSoldering
R2: 1k5; R_0805_HandSoldering
R11, R12: 2k7; R_0805_HandSoldering
R22, R24: 47; R_0805_HandSoldering
SW2: Config; SW_SPST_EVQPE1
U1: ATmega328P-AU; TQFP-32_7x7mm_Pitch0.8mm_HandSoldering
U2: CC1101; CC1101_SMD_noGDO2_Antenna
U3: AM1S-2403S; SIL-4
X1: P-250-204
X2: P-250-403

Connections:
+24V: D2.2, D11.1, D12.1, K1.1, K2.1, K2.8, X1.1
/BUTTON_DOWN: R23.1, R24.2, X2.1
/BUTTON_UP: R21.1, R22.2, X2.3
/CONFIG: SW2.2, U1.12
/CS: R3.2, U1.14, U2.8
/DOWN: C22.1, R24.1, U1.1
/DTR: C8.2, J2.1
/GDO0: U1.32, U2.7
/LED: R2.1, U1.2
/MISO: J3.1, U1.16, U2.5
/MOSI: J3.4, U1.15, U2.3
/Motor1: K1.9, X1.3
/Motor2: K1.4, X1.4
/REL_ON: R12.2, U1.24
/REL_POL: R11.2, U1.23
/RESET: C8.1, J3.5, R1.2, U1.29
/RX: J2.3, U1.30
/SCK: J3.3, U1.17, U2.4
/TX: J2.2, U1.31
/UP: C21.1, R22.1, U1.10
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C21.2, C22.2, D1.1, J2.5, J2.6, J3.6, K1.5, K1.10, Q1.2, Q2.2, SW2.1, U1.3, U1.5, U1.21, U2.2, U2.10, U2.11, U3.1, U3.3, X1.2, X2.2
unnamed: C4.1, U1.20
unnamed: C7.1, D2.1, U3.2
unnamed: D1.2, R2.2
unnamed: D11.2, K1.12, Q1.3
unnamed: D12.2, K2.12, Q2.3
unnamed: J1.1, U2.9
unnamed: K1.3, K1.8, K2.9
unnamed: Q1.1, R11.1
unnamed: Q2.1, R12.1
VCC: C1.1, C2.1, C3.1, C6.1, J2.4, J3.2, R1.1, R3.1, R21.2, R23.2, U1.4, U1.6, U1.18, U2.1, U3.4

## KiCad design AskSinAnalyzer/AskSinAnalyzer.kicad_pcb

File AskSinAnalyzer/README.md:

# AskSin Analyzer PCB     

Eine Platine für den [AskSinAnalyzer von Jérôme](https://github.com/jp112sdl/AskSinAnalyzer). 

## Weitere Infos sind im [Wiki](https://github.com/stan23/myPCBs/wiki)

## Gehäuse
[Ein Gehäuse gibt es auf Thingiverse](https://www.thingiverse.com/thing:3788587)

## Bilder

Dieses Werk ist lizenziert unter einer [Creative Commons Namensnennung - Nicht-kommerziell - Weitergabe unter gleichen Bedingungen 4.0 International Lizenz](http://creativecommons.org/licenses/by-nc-sa/4.0/).

Parts:
JP1, JP2: SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm

Connections:
/sheetAtmega/ATmega_RX: JP1.2 (B); also elsewhere on the board
/sheetAtmega/ATmega_TX: JP2.2 (B); also elsewhere on the board
/sheetEsp/ESP_RX2: JP2.1 (A); also elsewhere on the board
/sheetEsp/ESP_TX2: JP1.1 (A); also elsewhere on the board

Parts:
C11, C13: 10u; C_0805_HandSoldering; LCSC C15850
C12, C14, C15: 100n; C_0805_HandSoldering; LCSC C49678
J11: FTDI_ESP; Pin_Header_Straight_1x06_Pitch2.54mm_Tight_Fit
LED11: YELLOW; LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm
Q11, Q12: BC817; SOT-23_Handsoldering; LCSC C2137
R11, R13, R14, R15: 10k; R_0805_HandSoldering; LCSC C17414
R12: 330; R_0805_HandSoldering; LCSC C17630
SW11: DIP4; SW_DIP_x4_W7.62mm_Slide
SW12: Boot; SW_PUSH_6mm
SW13: Button; SW_PUSH_6mm
SW14: Reset; SW_PUSH_6mm
U11: TJCTM24028-SPI
U12: ESP-WROOM-32; ESP-WROOM-32_handsoldering

Connections:
/sheetEsp/BUTTON1: SW13.1, U12.23 (IO15)
/sheetEsp/EN: C15.1, Q12.3 (C), R11.2, SW14.1, U12.3 (EN)
/sheetEsp/ESP_DTR: Q11.2 (E), R14.2; also elsewhere on the board
/sheetEsp/ESP_RTS: Q12.2 (E), R13.2; also elsewhere on the board
/sheetEsp/ESP_RX: J11.3 (TX), U12.34 (RXD0/IO3); also elsewhere on the board
/sheetEsp/ESP_RX2: U12.27 (IO16); also elsewhere on the board
/sheetEsp/ESP_TX: J11.2 (RX), U12.35 (TXD0/IO1); also elsewhere on the board
/sheetEsp/ESP_TX2: U12.28 (IO17); also elsewhere on the board
/sheetEsp/LED_AP: R12.2, U12.8 (IO32)
/sheetEsp/SD_CS: U11.20 (SD_~CS), U12.12 (IO27)
/sheetEsp/SD_TFT_MISO: U11.9 (MISO), U11.13 (T_MISO), U11.22 (SD_MISO), U12.31 (IO19)
/sheetEsp/SD_TFT_MOSI: U11.6 (MOSI), U11.12 (T_MOSI), U11.21 (SD_MOSI), U12.37 (IO23)
/sheetEsp/SD_TFT_SCK: U11.7 (SCK), U11.10 (T_CLK), U11.23 (SD_SCK), U12.30 (IO18)
/sheetEsp/SW1_DETAIL: SW11.1, U12.14 (IO12)
/sheetEsp/SW2_ONLINE: SW11.2, U12.13 (IO14)
/sheetEsp/SW3_LINES: SW11.3, U12.16 (IO13)
/sheetEsp/SW4_UNUSED: SW11.4, U12.26 (IO4)
/sheetEsp/TFT_CS: U11.3 (~CS), U12.29 (IO5)
/sheetEsp/TFT_DC: U11.5 (D/~C), U12.10 (IO25)
/sheetEsp/TFT_LED: U11.8 (LED), U12.9 (IO33)
/sheetEsp/TFT_RESET: U11.4 (RESET), U12.11 (IO26)
/sheetEsp/T_CS: Q11.3 (C), R15.2, SW12.1, U11.11 (T_~CS), U12.25 (IO0)
/sheetEsp/T_IRQ: U11.14 (T_IRQ), U12.24 (IO2)
GND: C11.2, C12.2, C13.2, C14.2, C15.2, J11.6 (GND), LED11.1 (K), SW11.5, SW11.6, SW11.7, SW11.8, SW12.2, SW13.2, SW14.2, U11.2 (GND), U12.1 (GND), U12.15 (GND), U12.38 (GND), U12.39 (GND); also elsewhere on the board
unnamed: LED11.2 (A), R12.1
unnamed: Q11.1 (B), R13.1
unnamed: Q12.1 (B), R14.1

Parts:
C21: 10u; C_0805_HandSoldering; LCSC C15850
C22, C23, C25, C26: 100n; C_0805_HandSoldering; LCSC C49678
C24: 1u; C_0805_HandSoldering; LCSC C28323
J21: FTDI_ATmega; Pin_Header_Straight_1x06_Pitch2.54mm_Tight_Fit
J22: ISP; Pin_Header_Straight_2x03_Pitch2.54mm_Tight_Fit
J23: Conn_Coaxial; SMA_THT_Jack_Straight
LED21: GREEN; LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm
R21, R23: 10k; R_0805_HandSoldering; LCSC C17414
R22: 1M; R_0805_HandSoldering; LCSC C17514
R24: 330; R_0805_HandSoldering; LCSC C17630
U21: CC1101; CC1101_SMD_THT_Antenna
U22: ATmega328P-AU; TQFP-32_7x7mm_Pitch0.8mm_HandSoldering; LCSC C14877
Y21: 8M; Resonator_SMD_muRata_CSTCC-CSTCE-universal-3pin_7.2x3.0mm_H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

Connections:
/sheetAtmega/ATmega_RX: J21.3 (TX), U22.30 (PD0); also elsewhere on the board
/sheetAtmega/ATmega_TX: J21.2 (RX), U22.31 (PD1); also elsewhere on the board
/sheetAtmega/CS: R21.2, U21.8 (CSN), U22.14 (PB2)
/sheetAtmega/DTR: C25.2, J21.1 (DTR)
/sheetAtmega/GDO0: U21.7 (GDO0), U22.32 (PD2)
/sheetAtmega/LED_RX: R24.2, U22.2 (PD4)
/sheetAtmega/MISO: J22.1 (MISO), U21.5 (SO), U22.16 (PB4)
/sheetAtmega/MOSI: J22.4 (MOSI), U21.3 (SI), U22.15 (PB3)
/sheetAtmega/RESET: C25.1, J22.5 (~RST), R23.1, U22.29 (~RESET~/PC6)
/sheetAtmega/SCK: J22.3 (SCK), U21.4 (SCLK), U22.17 (PB5)
GND: C21.2, C22.2, C23.2, C24.2, C26.2, J21.5 (CTS), J21.6 (GND), J22.6 (GND), J23.2 (Ext), LED21.1 (K), U21.2 (GND), U21.10 (GND), U21.11 (GND), U22.3 (GND), U22.5 (GND), U22.21 (GND), Y21.2; also elsewhere on the board
unnamed: C23.1, U22.20 (AREF)
unnamed: J23.1 (In), U21.9 (ANT)
unnamed: LED21.2 (A), R24.1
unnamed: R22.1, U22.7 (XTAL1/PB6), Y21.1
unnamed: R22.2, U22.8 (XTAL2/PB7), Y21.3

Parts:
C1, C2: 22u; CP_Tantalum_Case-B_EIA-3528-21_Hand; LCSC C110051
C3: 10n; C_0805_HandSoldering; LCSC C1710
C4, C5, C7: 100n; C_0805_HandSoldering
C6: 4u7; CP_Tantalum_Case-B_EIA-3528-21_Hand
FB1: Ferrite_Bead; R_0805_HandSoldering; LCSC C16903
J1: Supply; Pin_Header_Straight_1x02_Pitch2.54mm
J2: USB_B_Micro; USB_Micro
Q1: IRLML5203; SOT-23_Handsoldering; LCSC C2592
R1: 100k; R_0805_HandSoldering; LCSC C17407
R2: 200; R_0805_HandSoldering; LCSC C17540
SW1: SW_DPDT_x2; SW_CuK_JS202011CQN_DPDT_Straight
U1: LM1117-3.3; SOT-223; LCSC C23984
U2: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm_Handsoldering

Connections:
+5V: C1.1, C6.1, C7.1, FB1.1, Q1.2 (S), U1.3 (VI), U2.20 (VCC)
/sheetAtmega/ATmega_RX: SW1.1 (A); also elsewhere on the board
/sheetAtmega/ATmega_TX: SW1.4 (A); also elsewhere on the board
/sheetEsp/ESP_DTR: U2.2 (DTR); also elsewhere on the board
/sheetEsp/ESP_RTS: U2.3 (RTS); also elsewhere on the board
/sheetEsp/ESP_RX: SW1.3 (C); also elsewhere on the board
/sheetEsp/ESP_TX: SW1.6 (C); also elsewhere on the board
/sheetSupply/D+: J2.3 (D+), R2.1, U2.15 (USBD+)
/sheetSupply/D-: J2.2 (D-), R2.2, U2.16 (USBD-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.2, J2.5 (GND), J2.6 (Shield), R1.2, U1.1 (GND), U2.7 (GND), U2.18 (GND), U2.21 (GND), U2.25 (AGND), U2.26 (TEST); also elsewhere on the board
unnamed: C3.1, FB1.2, J2.1 (VBUS)
unnamed: C4.1, U2.17 (3V3OUT)
unnamed: J1.1, Q1.3 (D)
unnamed: Q1.1 (G), R1.1
unnamed: SW1.2 (B), U2.1 (TXD)
unnamed: SW1.5 (B), U2.5 (RXD)

Notes on the sheet:
Option 2: direct supply
Option 1: USB for supply only
Option 3: USB for supply and debugging
optional switch to route RX/TX to ATmega or ESP automatic reset is available for ESP only!

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
Board: 2 copper layers, 92.5 x 61.2 mm, 55 parts (1 on the bottom side), 52 nets.

Notices in the files:
AskSinAnalyzer/AskSinAnalyzer.kicad_pcb:
CC BY-NC-SA
AskSinAnalyzer/README.md:
License: CC BY-NC-SA 4.0
Creative Commons Lizenzvertrag
HM-LC-Bl1-FM-DC/HM-LC-Bl1-FM-DC.kicad_pcb:
CC BY-NC-SA 4.0
