# Repository stan23/myPCBs (continued)

## KiCad design HB-MOD-UART-USB/HB-MOD-UART-USB.kicad_pcb

File HB-MOD-UART-USB/README.md:

## HB-MOD-UART-USB Platine
Ein USB-Stick mit HM-MOD-UART Funkmodul und FT232R, basierend auf @alexreinert's [HB-RF-USB](https://github.com/alexreinert/PCB/#hb-rf-usb). 

❗ Inzwischen unterstützt eQ-3s [HmIP-RFUSB](https://de.elv.com/elv-homematic-ip-arr-bausatz-rf-usb-stick-fuer-alternative-steuerungsplattformen-hmip-rfusb-fuer-smart-home-hausautomation-152306) sowohl [HM- als auch HmIP-Geräte](https://homematic-forum.de/forum/viewtopic.php?f=56&t=70936) und ist eine einfache Alternative.

### Parts

[Reichelt Teileliste](https://www.reichelt.de/my/1657385)

|Reference   |Quantity|Value       |Footprint                                                  |Datasheet                                                                             |
|------------|--------|------------|-----------------------------------------------------------|--------------------------------------------------------------------------------------|
|C2 C3 C4 C1 |4       |100nF       |Capacitors_SMD:C_0603_HandSoldering                        |~                                                                                     |
|C5          |1       |100u / 10V  |Capacitors_Tantalum_SMD:CP_Tantalum_Case-B_EIA-3528-21_Wave|~                                                                                     |
|C7          |1       |10nF        |Capacitors_SMD:C_0603_HandSoldering                        |~                                                                                     |
|C8          |1       |4.7uF       |Capacitors_SMD:C_0603_HandSoldering                        |~                                                                                     |
|C9          |1       |4.7nF       |Capacitors_SMD:C_0603_HandSoldering                        |~                                                                                     |
|D1          |1       |RX/TX       |LEDs:LED_0603_HandSoldering                                |~                                                                                     |
|J1          |1       |USB         |myConnectors:USB_A                                         |https://www.reichelt.de/usb-einbaustecker-typ-a-gew-pcb-lum-2410-08-p116154.html      |
|L1          |1       |Ferrite Bead BLM21 30 Ohm|Inductors_SMD:L_0805_HandSoldering                         |~                                                                                     |
|Q1          |1       |IRLML6402   |TO_SOT_Packages_SMD:SOT-23                                 |https://www.infineon.com/dgdl/irlml6402pbf.pdf?fileId=5546d462533600a401535668d5c2263c|
|R1          |1       |10K         |Resistors_SMD:R_0603_HandSoldering                         |~                                                                                     |
|R2          |1       |1K          |Resistors_SMD:R_0603_HandSoldering                         |~                                                                                     |
|R3 R5       |2       |1k          |Resistors_SMD:R_0603_HandSoldering                         |~                                                                                     |
|R4          |1       |1M          |Resistors_SMD:R_0603_HandSoldering                         |~                                                                                     |
|R6          |1       |270         |Resistors_SMD:R_0603_HandSoldering                         |~                                                                                     |
|U1          |1       |FT232RL     |myHousings:SSOP-28_5.3x10.2mm_Pitch0.65mm_Handsoldering    |http://www.ftdichip.com/Products/ICs/FT232RL.htm                                      |

Board: 2 copper layers, 34.3 x 17.8 mm, 20 parts (1 on the bottom side), 17 nets.

Parts:
C1, C2, C3, C4: 100nF; C_0603_HandSoldering
C5: 100u / 10V; CP_Tantalum_Case-B_EIA-3528-21_Wave
C7: 10nF; C_0603_HandSoldering
C8: 4.7uF; C_0603_HandSoldering
C9: 4.7nF; C_0603_HandSoldering
D1: RX/TX; LED_0603_HandSoldering
J1: USB; USB_A
L1: Ferrite Bead; L_0805_HandSoldering
Q1: IRLML6402; SOT-23
R1: 10K; R_0603_HandSoldering
R2: 1K; R_0603_HandSoldering
R3, R5: 1k; R_0603_HandSoldering
R4: 1M; R_0603_HandSoldering
R6: 270; R_0603_HandSoldering
U1: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm_Handsoldering
U2: HM-MOD-UART; HM-MOD-UART_SMD

Connections:
+3.3VP: C3.1, C4.1, C5.1, Q1.3, U2.1
+3V3: C2.1, Q1.2, R1.1, R6.2, U1.4, U1.17
+5V: C1.2, C8.2, L1.1, U1.20
/D+: J1.3, U1.15
/D-: J1.2, U1.16
/PWREN: R1.2, R2.1, U1.12
/RESET: U1.14, U2.4
/RXD: R3.2, U1.5
/TXD: R5.2, U1.1
GND: C1.1, C2.2, C4.2, C5.2, C7.2, C8.1, C9.2, J1.4, R4.1, U1.7, U1.18, U1.21, U1.25, U1.26, U2.2
unnamed: C3.2, Q1.1, R2.2
unnamed: C7.1, J1.1, L1.2
unnamed: C9.1, J1.5, R4.2
unnamed: D1.1, U1.23
unnamed: D1.2, R6.1
unnamed: R3.1, U2.5
unnamed: R5.1, U2.6

## KiCad design HB-MOD-UART/HB-MOD-UART.kicad_pcb

File HB-MOD-UART/README.md:

## HB-MOD-UART PCB
Eine Platine für das HM-MOD-UART Funkmodul mit SMA-Anschluss für eine externe Antenne.

Ein Gehäuse gibt es auf [Thingiverse](https://www.thingiverse.com/thing:4075549).

[Reichelt Teileliste](https://www.reichelt.de/my/1658779)

Parts:
C1: 100n; C_0805_HandSoldering
C2: 100u / 10V; CP_Tantalum_Case-B_EIA-3528-21_Hand
J1: Conn_Raspi; Pin_Header_Straight_2x06_Pitch2.54mm
J2: Conn_Coaxial; SMA_THT_Jack_Straight
JP1: ANT_GND; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2: 1k; R_0805_HandSoldering
U1: HM-MOD-UART; HM-MOD-UART_SMD_THT_Antenna

Connections:
+3V3: C1.1, C2.1, J1.1, U1.1 (VCC)
/RX: J1.10, R2.2
/TX: J1.8, R1.2
GND: C1.2, C2.2, J1.6, J1.9, JP1.1 (A), U1.2 (GND)
GNDS: J2.2 (Ext), JP1.2 (B), U1.10 (Shield)
unnamed: J1.12, U1.4 (C2CK)
unnamed: J2.1 (In), U1.9 (ANT)
unnamed: R1.1, U1.6 (RX)
unnamed: R2.1, U1.5 (TX)

Notes on the sheet:
+3V3 1 GPIO2 3 GPIO2 5 GPIO4 7 GND 9 GPIO17 11
2 +5V 4 +5V 6 GND 8 TXD0 10 RXD0 12 GPIO18

Board: 2 copper layers, 50.0 x 17.8 mm, 8 parts (5 on the bottom side), 9 nets.

## KiCad design HB-Mower-Fence/HB-Mower-Fence.kicad_pcb

File HB-Mower-Fence/README.md:

# HB-Mower-Fence     

Ein Signalgeber für den Begrenzungsdraht für Mähroboter, gesteuert über ein Homebrew HomeMatic-Gerät.

### Unbestückte Platinen gebe ich gerne zum Selbstkostenpreis ab.

# Hardware

### Bauteile

#### Reichelt

[Bestellliste](https://www.reichelt.de/my/1605116)

Bauteil         | Bestellnummer    | Anzahl | Kommentar
--------------- | ---------------- | ------ | ---------
C1              | X5R-G0805 10/16  |   1    | - 
C2, C3, C5, C6  | X7R-G0805 100N   |   4    | - 
C4              | X7R-G0805 1,0/25 |   1    | - 
C7, C8          | T491B 22U 16     |   2    | -
C9              | FC-A 2,2M 25     |   1    | -
D1              | 1N 4001          |   1    | -
J5              | WAGO 250-204     |   1    | -
LED1            | SMD-LED 0805 GE  |   1    | -
Q1              | IRLZ 44N         |   1    | -
Q2              | IRLML 5203       |   1    | -
R1, R3, R8      | RND 0805 1 10K   |   3    | - 
R2              | RND 0805 1 1,0M  |   1    | - 
R4              | RND 0805 1 330   |   1    | - 
R5, R6          | 11W AXIAL 18     |   2    | -
R7              | RND 0805 1 220   |   1    | - 
R9              | RND 0805 1 100K  |   1    | - 
SW1             | TASTER 3301      |   1    | -
U2              | ATMEGA 328P-AU   |   1    | - 
U3              | LM 1117 IMP3.3   |   1    | - 
Y1              | CSTCC 8,00       |   1    | -

#### Sonstiges

Bauteil | Bestellnummer              | Anzahl | Kommentar
------- | -------------------------- | ------ | ---------
U1      | CC1101 Funkmodul 868 MHz   |   1    | z.B. [eBay](https://www.ebay.de/itm/272455136087)

~8,3 cm Draht als Antenne

### Programmieradapter
- 1x ISP (z.B. [diesen hier](https://www.diamex.de/dxshop/USB-ISP-Programmer-fuer-Atmel-AVR-Rev2))

# Software

### Fuses

Fuse | Wert
---- | ---
Ext  | 0xFF
High | 0xD2
Low  | 0xE2

### Firmware

# Bauanleitung

Alle Bauteile sind in SMD Bauform 805 gewählt, um das Löten per Hand zu erleichtern.

Zuerst den ESP und den ATmega auflöten, die Markierung (kleiner Punkt) muss zur Beschriftung U2 zeigen.
Danach die anderen Bauteile (Kondensatoren, Widerstände, etc.) auflöten.

Mit einem Multimeter messen ob kein Kurzschluss zwischen VCC und GND besteht (mehrere 10 k Widerstand sind okay).

Mit dem ISP kann entweder direkt die Software aufgespielt werden, oder nur der Bootloader.
Durch die Verwendug des Bootloaders kann die Software bequem über den FTDI-Adapter geändert werden.

Pin am ISP-Kabel | Bedeutung
---------------- | ----------
1                | MISO
2                | VCC
3                | SCK
4                | MOSI
5                | Reset
6                | GND

Anschließend kann das Funkmodul aufgelötet werden. Dabei gibt es verschiedene Möglichkeiten:

Mit einem FTDI USB-seriell-Adapter an den Lötpunkten RX, TX, 3.3 V und GND und mit einem Terminalprogramm kann man die Ausgabe beobachten. 

# Bilder

Dieses Werk ist lizenziert unter einer [Creative Commons Namensnennung - Nicht-kommerziell - Weitergabe unter gleichen Bedingungen 4.0 International Lizenz](http://creativecommons.org/licenses/by-nc-sa/4.0/).

Board: 2 copper layers, 69.8 x 46.2 mm, 30 parts (6 on the bottom side), 24 nets.

Parts:
C1: 10u; C_0805_HandSoldering
C2, C3, C5, C6: 100n; C_0805_HandSoldering
C4: 1u; C_0805_HandSoldering
C7, C8: 22u; C_1206_HandSoldering
C9: 2200u; CP_Radial_D18.0mm_P7.50mm
D1: 1N4001; D_DO-41_SOD81_P12.70mm_Horizontal
J2: ISP; Pin_Header_Straight_2x03_Pitch2.54mm_Tight_Fit
J3: FTDI; Pin_Header_Straight_1x06_Pitch2.54mm_Tight_Fit
J5: P-250-204
LED1: GREEN; LED_0805_HandSoldering
Q1: IRLZ44N; TO-220
Q2: IRLML5203; SOT-23
R1, R3, R8: 10k; R_0805_HandSoldering
R2: 1M; R_0805_HandSoldering
R4: 330; R_0805_HandSoldering
R5: 18; R_Axial_Power_L50.0mm_W9.0mm_P60.96mm
R6: 18R 10W; R_Axial_Power_L50.0mm_W9.0mm_P60.96mm
R7: 220; R_0805_HandSoldering
R9: 100k; R_0805_HandSoldering
SW1: Config; SW_PUSH_6mm
U1: CC1101; CC1101_SMD_THT_Antenna
U2: ATmega328PB-AU; TQFP-32_7x7mm_Pitch0.8mm_HandSoldering
U3: LM1117-3.3; SOT-223
Y1: 8M; Resonator_SMD_muRata_CSTCC-3pin_7.2x3.0mm_HandSoldering

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C8.1, J2.2, J3.4, R1.1, R3.2, U1.1, U2.4, U2.18, U3.2
+12V: J5.1, Q2.3, R5.1, R6.1
/CONFIG: SW1.1, U2.12
/CS: R1.2, U1.8, U2.14
/D5: R7.2, U2.9
/DTR: C6.2, J3.1
/GDO0: U1.7, U2.32
/LED: R4.2, U2.2
/MISO: J2.1, U1.5, U2.16
/MOSI: J2.4, U1.3, U2.15
/RESET: C6.1, J2.5, R3.1, U2.29
/RX: J3.3, U2.30
/SCK: J2.3, U1.4, U2.17
/TX: J3.2, U2.31
/WIRE+: C9.1, D1.1, J5.3, R5.2, R6.2
/WIRE-: D1.2, J5.4, Q1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, J2.6, J3.5, J3.6, J5.2, LED1.1, Q1.2, R8.2, R9.2, SW1.2, U1.2, U1.10, U1.11, U2.5, U2.21, U3.1, Y1.2
unnamed: C5.1, U2.20
unnamed: C7.1, Q2.2, U3.3
unnamed: LED1.2, R4.1
unnamed: Q1.1, R7.1, R8.1
unnamed: Q2.1, R9.1
unnamed: R2.1, U2.7, Y1.1
unnamed: R2.2, U2.8, Y1.3

## KiCad design Analyzer/Analyzer.kicad_pcb

Parts:
C1: 10µ; CP_Radial_D4.0mm_P1.50mm
D1, D2: LED; LED_D3.0mm
J1: 5V; PinHeader_1x02_P2.54mm_Vertical
R1, R2: 330; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R3: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
SW1: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W7.62mm_P2.54mm_LowProfile
SW2: SW_Push; SW_PUSH_6mm_H4.3mm
U1: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D
U2: 2.8_240x320_touch_sd_spi; 2.8_tft_240x320_touch_sd_spi
U3: arduino-pro-mini; ArduinoProMini
U4: CC1101; CC1101-868MHz-Module-neu
U5: IRLU024N; TO-251-3_Vertical

Connections:
+3V3: U1.1 (3V3), U2.1, U3.21 (VCC), U4.1 (VCC)
+5V: C1.1, J1.1, R3.1, U1.19 (EXT_5V)
CS: U1.29 (IO5), U2.3
CSN: U3.13 (D10), U4.8 (CSN)
DC: U1.9 (IO25), U2.5
GDO0: U3.5 (D2), U4.7 (GDO0)
GND: C1.2, D1.1 (K), D2.1 (K), SW1.1, SW1.2, SW1.3, SW2.2, U1.20 (GND3), U2.2, U3.4 (GND), U3.23 (GND), U4.2 (GND), U5.3 (S)
LED: U1.8 (IO33), U2.8
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: J1.2, U5.2 (D)
unnamed: R1.2, U1.7 (IO32)
unnamed: R2.2, U3.7 (D4)
unnamed: R3.2, U5.1 (G)
unnamed: SW1.4, U1.15 (IO13)
unnamed: SW1.5, U1.13 (IO12)
unnamed: SW1.6, U1.12 (IO14)
unnamed: SW2.1, U1.35 (IO15)
RS: U1.10 (IO26), U2.4
SCK: U1.28 (IO18), U2.7, U2.15
SCL: U3.16 (D13), U4.4 (SCLK)
SDA: U1.21 (IO23), U2.6, U2.16
SDO: U1.27 (IO19), U2.9, U2.17
SD_SCK: U1.11 (IO27), U2.18
SI: U3.14 (D11), U4.3 (MOSI)
SO: U3.15 (D12), U4.5 (MISO)
TXD: U1.31 (IO16), U3.1 (TXD)

Notes on the sheet:
+ 5V
- 5V

Board: 2 copper layers, 59.7 x 91.4 mm, 14 parts (1 on the bottom side), 27 nets.

## Commit log

2019-05-10 Create LICENSE.md
    source:
    https://github.com/idleberg/Creative-Commons-Markdown/blob/master/4.0/by-nc-sa.markdown
2019-05-22 Schematic + Board V1.0
2019-05-22 add rendered picture
2019-05-22 add pictures
2019-05-24 update BOM
2019-05-24 linkfix
2019-06-30 Revert "initial commit"
    This reverts commit 4ba7e756ae3ff0d14893c76a2404fe6f690aaec2.
2019-07-06 Analyzer PCB
2019-07-07 AskSinAnalyzer PCB
2019-07-07 adding libraries
2019-07-07 PCB update
    reference labels moved
2019-07-08 antenna added
2019-07-08 new microUSB connector
2019-07-14 PCB update
    pads for ESP made longer
2019-07-14 HB-Mower-Fence
2019-07-15 add rendered PCB images
2019-07-15 fix BOM
2019-07-22 more pictures
2019-07-22 add short description and links
2019-08-02 add HB-Dis-EP-42BW
2019-08-02 BOM updated
2019-08-02 link to pictures
2019-08-04 link to thingiverse
2019-08-11 no PCBs left
2019-08-26 AskSinAnalyzer PCB V2.0 RC1
    added a FTDI FT245 to flash and debug ESP32
2019-09-12 AskSinAnalyzer PCB V2.0
2019-09-12 KiCad parts library updates
2019-09-13 add rendered pictures
2019-09-13 PCB update for 3D modells
2019-09-23 Verfügbarkeit
2019-10-02 add links for LCD
2019-10-07 moved descrption to wiki
2019-10-15 PCB availability
2019-11-14 HB-MOD-UART V1.0
2019-11-14 moved HB-MOD-UART
2019-11-14 fixed CC1101 module footprint
2019-11-14 add HM-MOD-UART footprint
2019-11-23 HB-MOD-UART: swap RX/TX
    fixes #3
2019-12-31 add pictures of HB-MOD-UART
2019-12-31 add description of HB-MOD-UART
2019-12-31 README.md for HB-MOD-UART
2020-01-03 add STEP models
    for
    - CC1101
    - HM-MOD-UART
    - USB plug
2020-01-03 add HB-MOD-UART-USB
2020-01-03 add USB A plug
2020-01-03 add link to HB-MOD-UART-USB
2020-01-03 README for HB-MOD-UART-USB
2020-01-03 schematic+board PDFs
2020-01-03 HB-MOD-UART-USB V1.1
    featuring a RX/TX LED
2020-01-08 add production data to AskSinAnalyzer PCB
2020-02-16 Reichelt part list added
2020-02-16 HB-MOD-UART-USB PDFs renamed
2020-06-14 no Analyzer PCBs left :(
2020-07-22 link to modified sketch for this PCB
2020-07-23 move HB-LC-Bl1-FM-DC from https://github.com/stan23/HM-LC-Bl1-FM-DC
2020-07-23 moved files
2020-07-23 moved some libs
2020-07-23 basic routing finished
2020-07-24 HM-LC-Bl1-FM-DC V3.0
2020-10-04 picture resized
2020-12-15 new PCB: HB-LC-Dim6PMW-CV
2020-12-16 HB-LC-Dim6PWM-CV: add EEPROM
2021-02-03 Teileliste: C7, C8 -> RND 1500805N120
2021-05-17 HM-LC-Bl1-FM-DC pictures
2023-08-20 move symbol libs to KiCad 7
2023-08-31 add dimmer shield for AskSinDuino32
2023-09-03 HB-LC-Dim5PWM-CV_AskSinDuino32Shield
    - 5th channel
    - SMD FETs
    - mounting holes
    - PCB size and routing optimized
2023-09-03 small improvements in supply layer
2023-09-15 V0.6: fix wrong VCC connection on module
2024-01-08 fuse correction
2024-02-10 fix Reichelt-link
2024-02-11 Teileliste
